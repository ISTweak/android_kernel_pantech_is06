## drivers/misc/tspdrv/Kconfig
```kconfig
# shpark 091229 add
# -----------------

config TSPDRV
	tristate "IMMERSION TouchSense Player driver"
```
